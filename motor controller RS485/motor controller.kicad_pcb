# Repository keionbis/ServoControllerRev2

## KiCad design motor controller RS485/motor controller.kicad_pcb

Parts:
C1, C2: C; C_0402_1005Metric
C3: 1UF; C_0402_1005Metric
C4: 0.1UF; C_0402_1005Metric
C5: 1uf; C_0402_1005Metric
C6: 33nf; C_0402_1005Metric
C7: 47UF; C_1206_3216Metric
D1: LED; LED_0603_1608Metric
IC1: MA702
IC2: MC33926PNB; QFN80P800X800X220-33N; Manufacturer_Part_Number MC33926PNB
IC3: SN65HVD75DRBT; SON65P300X300X100-9N-D; Manufacturer_Part_Number SN65HVD75DRBT; Mouser Part Number 595-SN65HVD75DRBT
J1, J2: Conn_01x04_Male; Molex_CLIK-Mate_502494-0470_1x04-1MP_P2.00mm_Horizontal
J3: Conn_01x04_Male; 1x4Pads
M1: Motor_DC; hv5932mgMotor
R1: 100k; R_0402_1005Metric
R2: 330; R_0402_1005Metric
R3: 10K; R_0402_1005Metric
R4: 220; R_0402_1005Metric
R5, R6, R7, R8, R9: 1k; R_0402_1005Metric
U1: STM32L432KCUx; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm
U2: MIC5504-3.3YM5; SOT-23-5

Connections:
+3V3: C2.2, C3.1, IC1.13 (VDD), IC2.10 (EN), IC3.8 (VCC), J3.2, R7.2, U1.1 (VDD), U1.5 (VDDA), U1.17 (VDD), U2.5 (VOUT)
+BATT: C1.2, C4.1, C6.1, C7.1, IC2.4 (VPWR_1), IC2.6 (VPWR_2), IC2.11 (VPWR_3), IC2.31 (VPWR_4), J1.4, J2.1, J2.MP, U2.1 (VIN), U2.3 (EN)
A: IC3.6 (A), J1.2, J2.3
B: IC3.7 (B), J1.3, J2.2
D1: R8.1, U1.20 (PA10)
D2: R9.2, U1.18 (PA8)
DIR: IC3.2 (~RE), IC3.3 (DE), R3.2, U1.10 (PA4)
ENC_CS: IC1.5 (CS), U1.29 (PB6)
FB: C5.1, IC2.8 (FB), R4.1, U1.14 (PB0)
GND: C1.1, C2.1, C3.2, C4.2, C5.2, C7.2, D1.1 (K), IC1.8 (GND), IC1.17 (EP), IC2.18 (PGND_1), IC2.19 (PGND_2), IC2.20 (PGND_3), IC2.22 (PGND_4), IC2.23 (PGND_5), IC2.24 (PGND_6), IC2.33 (EP_AGND), IC3.5 (GND), IC3.9 (EPAD), J1.1, J2.4, J3.1, R1.2, R3.1, R4.2, U1.16 (VSS), U1.32 (VSS), U1.33 (VSS), U2.2 (GND)
IN1: R6.2, U1.15 (PB1)
IN2: R5.2, U1.19 (PA9)
MISO: IC1.7 (MISO), U1.27 (PB4)
MOSI: IC1.4 (MOSI), U1.28 (PB5)
unnamed: C6.2, IC2.32 (CCP)
unnamed: D1.2 (A), R2.1
unnamed: IC2.1 (IN2), R5.1
unnamed: IC2.2 (IN1), R6.1
unnamed: IC2.3 (SLEW), R7.1
unnamed: IC2.16 (~D2), R9.1
unnamed: IC2.26 (D1), R8.2
unnamed: R1.1, U1.31 (PH3)
OUT1: IC2.12 (OUT1_1), IC2.13 (OUT1_2), IC2.14 (OUT1_3), IC2.15 (OUT1_4), M1.2 (-)
OUT2: IC2.27 (OUT2_1), IC2.28 (OUT2_2), IC2.29 (OUT2_3), IC2.30 (OUT2_4), M1.1 (+)
RX: IC3.1 (R), U1.9 (PA3)
SCK: IC1.12 (SCLK), U1.26 (PB3)
SWCLK: J3.4, U1.24 (PA14)
SWDIO: J3.3, U1.23 (PA13)
TX: IC3.4 (D), U1.8 (PA2)

Board: 4 copper layers, 38.0 x 18.0 mm, 24 parts (13 on the bottom side), 28 nets.

File BOM.csv:

"Id";"Designator";"Package";"Quantity";"Designation";"Supplier and ref";
1;"C1,C2";"C_0402_1005Metric";2;"10pF";;;
2;"C3,C8,C9";"C_0402_1005Metric";3;"1UF";;;
3;"C5";"C_0402_1005Metric";1;"1uf";;;
4;"C6";"C_0402_1005Metric";1;"33nf";;;
5;"C7";"C_1206_3216Metric";1;"47UF";;;
6;"IC1";"MA702";1;"MA702";;;
7;"IC2";"QFN80P800X800X220-33N";1;"MC33926PNB";;;
8;"J1,J2";"Molex_CLIK-Mate_502443-0670_1x06-1MP_P2.00mm_Vertical";2;"Conn_01x06_Male";;;
9;"R1";"R_0402_1005Metric";1;"100k";;;
10;"R4";"R_0402_1005Metric";1;"220";;;
11;"R5,R6,R7,R8,R9";"R_0402_1005Metric";5;"1k";;;
12;"C4";"C_0402_1005Metric";1;"0.1UF";;;
13;"Y1";"ECX-1247";1;"32mhz";;;
14;"IC3";"SON95P300X300X80-7N";1;"LP38690SD-ADJ_NOPB";;;
15;"J3";"1x4Pads";1;"Conn_01x04_Male";;;
16;"M1";"hv5932mgMotor";1;"Motor_DC";;;
17;"U1";"QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm";1;"STM32L432KCUx";;;

## KiCad design motor controller Mini(SPI)/motor controller.kicad_pcb

Parts:
C1, C2: 0.1uF; C_0201_0603Metric
C3, C8, C9: 1uF; C_0201_0603Metric
C6: 0.1UuF; C_0201_0603Metric
C7: 47pF; C_0402_1005Metric
C10, C11: 100nF; C_0201_0603Metric
FB1, FB2: Ferrite_Bead; L_0603_1608Metric
IC1: MA702
IC3: MIC5501-3.0YM5-TR; SOT95P280X130-5N; Manufacturer_Part_Number MIC5501-3.0YM5-TR
IC4: DRV8837CDSGT; SON50P200X200X80-9N; Manufacturer_Part_Number DRV8837CDSGT
J2: Conn_01x06_Male; Molex_CLIK-Mate_502386-0670_1x06-1MP_P1.25mm_Horizontal
J3: Conn_01x04_Male; 1x4Pads
M1: Motor_DC; mg92b
R1: 100k; R_0201_0603Metric
R2: 1k; R_0201_0603Metric
R3: 550; R_0201_0603Metric
R4: 0.33; R_0805_2012Metric
U1: STM32L432KCUx; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm

Connections:
+3V3: C2.2, C3.1, C9.1, IC1.13 (VDD), IC3.5 (VOUT), IC4.7 (NSLEEP), IC4.8 (VCC), J3.4, U1.1 (VDD), U1.5 (VDDA), U1.17 (VDD)
+BATT: C1.2, C8.2, IC3.1 (VIN), IC4.1 (VM), J2.6, R2.2
CS: J2.1, U1.9 (PA3)
ENC_CS: IC1.5 (CS), U1.10 (PA4)
FB: C6.2, IC4.4 (GND), R4.1, U1.15 (PB1)
GND: C1.1, C2.1, C3.2, C6.1, C8.1, C9.2, C10.1, C11.1, IC1.8 (GND), IC1.17 (EP), IC3.3 (EN), IC4.9 (EP), J2.5, J3.3, R1.2, R3.1, R4.2, U1.16 (VSS), U1.32 (VSS), U1.33 (VSS)
IN1: IC4.6 (IN1), U1.20 (PA10)
IN2: IC4.5 (IN2), U1.19 (PA9)
MISO: IC1.7 (MISO), U1.12 (PA6)
MISO2: J2.3, U1.27 (PB4)
MOSI: IC1.4 (MOSI), U1.13 (PA7)
MOSI2: J2.2, U1.28 (PB5)
unnamed: FB1.1, IC4.2 (OUT1)
unnamed: FB2.1, IC4.3 (OUT2)
unnamed: R1.1, U1.31 (PH3)
OUT1: C7.1, C10.2, FB1.2, M1.2 (-)
OUT2: C7.2, C11.2, FB2.2, M1.1 (+)
PREF: R2.1, R3.2, U1.7 (PA1)
SCK: IC1.12 (SCLK), U1.11 (PA5)
SCK2: J2.4, U1.26 (PB3)
SWCLK: J3.1, U1.24 (PA14)
SWDIO: J3.2, U1.23 (PA13)

Board: 4 copper layers, 21.0 x 10.5 mm, 22 parts (8 on the bottom side), 22 nets.

## KiCad design motor controller.kicad_pcb

Parts:
C1, C2: 10pF; C_0402_1005Metric
C3, C8, C9: 1UF; C_0402_1005Metric
C4: 0.1UF; C_0402_1005Metric
C5: 1uf; C_0402_1005Metric
C6: 33nf; C_0402_1005Metric
C7: 47UF; C_1206_3216Metric
D1: LED; LED_0603_1608Metric
IC1: MA702
IC2: MC33926PNB; QFN80P800X800X220-33N; Manufacturer_Part_Number MC33926PNB
IC3: LP38690SD-ADJ_NOPB; SON95P300X300X80-7N; Manufacturer_Part_Number LP38690SD-ADJ/NOPB
J1, J2: Conn_01x06_Male; Molex_CLIK-Mate_502443-0670_1x06-1MP_P2.00mm_Vertical
J3: Conn_01x04_Male; 1x4Pads
M1: Motor_DC; hv5932mgMotor
R1: 100k; R_0402_1005Metric
R2: 330; R_0402_1005Metric
R4: 220; R_0402_1005Metric
R5, R6, R7, R8, R9: 1k; R_0402_1005Metric
U1: STM32L432KCUx; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm
Y1: 32mhz; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3V3: C3.1, C9.1, IC1.13 (VDD), IC2.10 (EN), IC3.4, IC3.5, J3.2, R7.2, U1.1 (VDD), U1.5 (VDDA), U1.17 (VDD)
+BATT: C4.1, C6.1, C7.1, C8.2, IC2.4 (VPWR_1), IC2.6 (VPWR_2), IC2.11 (VPWR_3), IC2.31 (VPWR_4), IC3.1, IC3.6, J1.1, J2.6
CS: J1.6, J2.1, U1.10 (PA4)
D1: R8.1, U1.26 (PB3)
D2: R9.2, U1.22 (PA12)
ENC_CS: IC1.5 (CS), U1.30 (PB7)
FB: C5.1, IC2.8 (FB), R4.1, U1.14 (PB0)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C7.2, C8.1, C9.2, D1.1 (K), IC1.8 (GND), IC1.17 (EP), IC2.18 (PGND_1), IC2.19 (PGND_2), IC2.20 (PGND_3), IC2.22 (PGND_4), IC2.23 (PGND_5), IC2.24 (PGND_6), IC2.33 (EP_AGND), IC3.2, IC3.7, J1.2, J2.5, J3.1, R1.2, R4.2, U1.16 (VSS), U1.32 (VSS), U1.33 (VSS), Y1.2, Y1.4
IN1: R6.2, U1.25 (PA15)
IN2: R5.2, U1.15 (PB1)
MISO: IC1.7 (MISO), J2.3, U1.12 (PA6)
MOSI: IC1.4 (MOSI), J1.3, U1.13 (PA7)
unnamed: C1.1, U1.2 (PC14), Y1.1
unnamed: C2.2, U1.3 (PC15), Y1.3
unnamed: C6.2, IC2.32 (CCP)
unnamed: D1.2 (A), R2.1
unnamed: IC2.1 (IN2), R5.1
unnamed: IC2.2 (IN1), R6.1
unnamed: IC2.3 (SLEW), R7.1
unnamed: IC2.16 (~D2), R9.1
unnamed: IC2.26 (D1), R8.2
unnamed: J1.4, J2.4
unnamed: R1.1, U1.31 (PH3)
OUT1: IC2.12 (OUT1_1), IC2.13 (OUT1_2), IC2.14 (OUT1_3), IC2.15 (OUT1_4), M1.2 (-)
OUT2: IC2.27 (OUT2_1), IC2.28 (OUT2_2), IC2.29 (OUT2_3), IC2.30 (OUT2_4), M1.1 (+)
SCK: IC1.12 (SCLK), J1.5, J2.2, U1.11 (PA5)
SWCLK: J3.3, U1.24 (PA14)
SWDIO: J3.4, U1.23 (PA13)
signaling: R2.2, U1.6 (PA0)

Board: 2 copper layers, 38.0 x 18.0 mm, 27 parts (13 on the bottom side), 29 nets.

File motor controller SPI (Right Angle)/motor controller_bom_.csv:

Component,Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet,Manufacturer_Name,Arrow Part Number,Height,Arrow Price/Stock,RS Price/Stock,RS Part Number,Manufacturer_Part_Number
1,Unpolarized capacitor,C,C4,0.1UF,C_0402_1005Metric,1,~,,,,,,,
2,Unpolarized capacitor,C,C1 C2,10pF,C_0402_1005Metric,2,~,,,,,,,
3,Unpolarized capacitor,C,C3 C5 C8 C9,1UF,C_0402_1005Metric,4,~,,,,,,,
4,Unpolarized capacitor,C,C6,33nf,C_0402_1005Metric,1,~,,,,,,,
5,Unpolarized capacitor,C,C7,47UF,C_1206_3216Metric,1,~,,,,,,,
6,LED generic,LED,D1,LED,LED_0603_1608Metric,1,~,,,,,,,
7,"1A LDO Regulator Adj.,LP38690SD-ADJ Texas Instruments LP38690SD-ADJ/NOPB, LDO Voltage Regulator, Adjustable 1A, 1.25  9 V 2.5%, 6-Pin LLP",LP38690SD-ADJ_NOPB,IC3,LP38690SD-ADJ_NOPB,SON95P300X300X80-7N,1,http://uk.rs-online.com/web/p/products/6515542,Texas Instruments,LP38690SD-ADJ/NOPB,0.8,https://www.arrow.com/en/products/lp38690sd-adjnopb/texas-in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,http://uk.rs-online.com/web/p/products/6515542P,6515542P,LP38690SD-ADJ/NOPB
8,,MA702,IC1,MA702,MA702,1,,,,,,,,
9,Motor / Motion / Ignition Controllers & Drivers THROTTLE CTRL H-BRIDGE,MC33926PNB,IC2,MC33926PNB,QFN80P800X800X220-33N,1,http://cache.nxp.com/files/analog/doc/data_sheet/MC33926.pdf,Nexperia,MC33926PNB,2.2,https://www.arrow.com/en/products/mc33926pnb/nxp-semiconductors,,,MC33926PNB
10,"Generic connector, single row, 01x04, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x04_Male,J3,Conn_01x04_Male,1x4Pads,1,~,,,,,,,
11,"Generic connector, single row, 01x06, script generated (kicad-library-utils/schlib/autogen/connector/)",Conn_01x06_Male,J1 J2,Conn_01x06_Male,Molex_CLIK-Mate_502494-0670_1x06-1MP_P2.00mm_Horizontal,2,~,,,,,,,
12,DC Motor,Motor_DC,M1,Motor_DC,hv5932mgMotor,1,~,,,,,,,
13,Resistor,R,R1,100k,R_0402_1005Metric,1,~,,,,,,,
14,Resistor,R,R5 R6 R7 R8 R9,1k,R_0402_1005Metric,5,~,,,,,,,
15,Resistor,R,R4,220,R_0402_1005Metric,1,~,,,,,,,
16,Resistor,R,R2,330,R_0402_1005Metric,1,~,,,,,,,
17,"ARM Cortex-M4 MCU, 256KB flash, 64KB RAM, 80MHz, 1.71-3.6V, 26 GPIO, UFQFPN-32",STM32L432KCUx,U1,STM32L432KCUx,QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm,1,http://www.st.com/st-web-ui/static/active/en/resource/techni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,,,,,,,
18,"Four pin crystal (GND on pins 2 and 4), e.g. in SMD package",Crystal_GND24,Y1,32mhz,Crystal_SMD_2016-4Pin_2.0x1.6mm,1,~,,,,,,,

Component Groups:,18
Component Count:,27
Fitted Components:,27
Number of PCBs:,1
Total components:,27
Schematic Version:,
Schematic Date:,
BoM Date:,Sun 26 Aug 2018 06:05:22 PM EDT
Schematic Source:,/home/kbisland/Documents/MotorControllers/motor controller SPI (Right Angle)/motor controller.sch
KiCad Version:,Eeschema 5.0.0-fee4fd1~66~ubuntu16.04.1

## KiCad design motor controller Mini/SmallKat Jumbo Motherboard/SmallKat Jumbo Motherboard.kicad_pcb

Board: 2 copper layers, 80.0 x 80.0 mm, 49 parts (0 on the bottom side), 55 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17: C; C_0402_1005Metric
D1, D2: D; D_0402_1005Metric
IC1, IC2: TPS562201DDCR; SOT95P280X110-6N
J1, J2, J3, J4, J5, J6, J7, J8, J9, J10, J11, J16: Conn_01x06_Male; Molex_CLIK-Mate_502443-0670_1x06-1MP_P2.00mm_Vertical
J12, J14, J15: Conn_01x04_Male; Molex_CLIK-Mate_502443-0470_1x04-1MP_P2.00mm_Vertical
J13: Conn_01x02_Male; Molex_CLIK-Mate_502443-0270_1x02-1MP_P2.00mm_Vertical
L1, L2: L; L_1206_3216Metric
R1, R2, R3, R4, R5, R6, R7: R; R_0402_1005Metric
U1: STM32H753IITx; LQFP-176_24x24mm_P0.5mm
Y1, Y2: 32MHZ; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+3V3: C1.1, D1.1, D2.1, J12.3, J14.3, U1.15, U1.23, U1.36, U1.39, U1.49, U1.62, U1.72, U1.82, U1.91, U1.103, U1.114, U1.127, U1.136, U1.149, U1.159, U1.172
+5V: C14.2, C15.2, C16.2, IC2.3, J15.1, R6.1, R7.1
+BATT: C8.2, C9.2, C10.2, IC1.3, J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, J10.1, J11.1, J13.2, J16.1, R3.1, R4.1
CS1_1: J1.6, U1.56
CS1_2: J2.6, U1.57
CS1_3: J4.6, U1.58
CS1_4: J5.6, U1.161
CS2: J3.6, U1.162
CS3: J8.6, U1.163
CS4: J9.6, U1.164
CS5_1: J6.6, U1.165
CS5_2: J7.6, U1.167
CS5_3: J10.6, U1.168
CS5_4: J11.6, U1.79
CS6: J16.6, U1.80
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, C11.2, C12.2, C13.2, C14.1, C15.1, C16.1, C17.2, IC1.1, IC2.1, J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J7.2, J8.2, J9.2, J10.2, J11.2, J12.4, J13.1, J14.4, J15.4, J16.2, R1.2, R2.2, R5.2, U1.14, U1.22, U1.37, U1.48, U1.61, U1.71, U1.90, U1.102, U1.113, U1.126, U1.135, U1.148, U1.158, Y1.2, Y1.4, Y2.2, Y2.4
MISO1: J1.4, J2.4, J4.4, J5.4, U1.52
MISO2: J3.4, U1.94
MISO3: J8.4, U1.140
MISO4: J9.4, U1.76
MISO5: J6.4, J7.4, J10.4, J11.4, U1.26
MISO6: J16.4, U1.155
MOSI1: J1.5, J2.5, J4.5, J5.5, U1.53
MOSI2: J3.5, U1.95
MOSI3: J8.5, U1.141
MOSI4: J9.5, U1.77
MOSI5: J6.5, J7.5, J10.5, J11.5, U1.27
MOSI6: J16.5, U1.157
unnamed: C6.1, C7.1, D2.2, L1.1
unnamed: C11.1, IC1.6
unnamed: C12.1, C13.1, D1.2, L2.1
unnamed: C17.1, IC2.6
unnamed: IC1.2, L1.2
unnamed: IC1.4, R2.1, R4.2
unnamed: IC1.5, R3.2
unnamed: IC2.2, L2.2
unnamed: IC2.4, R5.1, R7.2
unnamed: IC2.5, R6.2
unnamed: R1.1, U1.166
OSCIN: C4.1, U1.29, Y2.1
OSCIN_32: C2.1, U1.9, Y1.1
OSCOUT: C5.1, U1.30, Y2.3
OSCOUT_32: C3.1, U1.10, Y1.3
RX: J14.2, U1.121
SCK1: J1.3, J2.3, J4.3, J5.3, U1.51
SCK2: J3.3, U1.93
SCK3: J8.3, U1.139
SCK4: J9.3, U1.75
SCK5: J6.3, J7.3, J10.3, J11.3, U1.25
SCK6: J16.3, U1.156
SWCLK: J12.1, U1.137
SWDIO: J12.2, U1.124
TX: J14.1, U1.120
USBDM: J15.2, U1.122
USBDP: J15.3, U1.123

## Commit log

2018-08-02 Updated locations and footprints
2018-08-09 Updated step
2018-08-22 Added allcurrent variations
2018-08-22 Removed files
2018-08-22 got all libs back
2018-10-24 Updated footprints
2018-11-12 Push to new server
2019-02-11 Updated RS485 variant
